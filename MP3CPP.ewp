# IAR project MP3CPP.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: inc; app; F5xx_F6xx_Core_Lib; FatFs; MSP430_FFTB_HAL
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6638.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: app; F5xx_F6xx_Core_Lib; FatFs; MSP430_FFTB_HAL
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: main.cpp
  group app
    app/: tm1638.c tm1638.h wav.c wav.h
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: hal_macros.h Hardware_Profile.h
  group FatFs
    FatFs/: diskio.h ff.c ff.h ffconf.h integer.h mmc.c mmc.h
  group inc
    inc/: base.h
  group MSP430_FFTB_HAL
    MSP430_FFTB_HAL/: HAL_SDCard.c HAL_SDCard.h
